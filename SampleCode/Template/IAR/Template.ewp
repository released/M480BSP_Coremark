# IAR project Template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: MAIN_HAS_NOARGC
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\Library\CMSIS\Include; ..\..\..\Library\Device\Nuvoton\M480\Include; ..\..\..\Library\StdDriver\inc; ..\Coremark; ..
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../../../Library/Device/Nuvoton/M480/Source/: system_M480.c
  group Coremark
    ../Coremark/: core_list_join.c core_main.c core_matrix.c core_state.c core_util.c
  group Library
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: core_portme.c main.c
